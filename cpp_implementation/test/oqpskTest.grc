options:
  parameters:
    generate_options: qt_gui
    id: oqpskTest
    output_language: python
    title: OQPSK Test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: OQPSK_mod_0
  id: OQPSK_mod
  parameters:
    alpha: '0.5'
    delay: '2'
    n_taps: '11'
    samp_rate: '32000'
    sps: '4'
    symbol_rate: '1'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (1, 0, 1, 0, 0, 1, 0, 1)
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [OQPSK_mod_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_source_x_0, '0', OQPSK_mod_0, '0']

metadata:
  file_format: 1
